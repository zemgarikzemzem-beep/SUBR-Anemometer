# Keil uVision project 1.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: 1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\lib;.\lib\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./: main.c
    ./lib/src/: adc.c data.c delay.c dht22.c exti.c fonts.c gpio.c rcc.c spi.c TDC1000.c tft.c tim.c
  group startup
    ./lib/: startup_stm32g431xx.s system_stm32g4xx.c
